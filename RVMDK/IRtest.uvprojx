# Keil uVision project IRtest.uvprojx, settings and files
target IR (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IRtest.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__CC_ARM
  c include: ..\Src;..\Src\System\CMSIS;..\Src\STM32F0xx_StdPeriph_Driver\inc;..\Src\OnChipDevice;..\Src\ExternalDevice;..\Src\Api\core\inc;..\Src\Api\platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group System
    ../Src/: main.c stm32f0xx_it.c
  group VL53L0/core
    ../Src/Api/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
  group VL53L0/platform
    ../Src/Api/platform/src/: vl53l0x_platform.c
  group STM32F0xx_StdPeriph_Driver
    ../Src/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_dac.c stm32f0xx_iwdg.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_wwdg.c
  group startup
    ../Src/System/startup/: startup_stm32f030x6.s
    ../Src/System/CMSIS/: system_stm32f0xx.c
  group OnChipDevice
    ../Src/OnChipDevice/: I2C.c
  group ExternalDevice
    ../Src/ExternalDevice/: vl53l0x_driver.c
